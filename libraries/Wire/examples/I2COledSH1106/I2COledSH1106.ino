// en: Show text and a counter on an SH1106 128x64 OLED over I2C, with Wire alone (no display library).
// ja: SH1106（128x64のOLED、I2C）に文字とカウンタを出す。Wireだけで動かす（表示のライブラリは使わない）。
// en: Wiring and operation: README.md.
// ja: 配線と操作: README.ja.md。

/* requires: I2C1 */

#include <Wire.h>

// en: The pins: this chip's default I2C pads. The WeAct CH32X035 (F8U6) has I2C only on the debug pads
// en: PC18 / PC19 (or the USB pads PC16 / PC17): there use PC18 / PC19 and USE_DEBUG_PADS 1.
// ja: 端子。この石の既定のI2Cの端子。WeAct CH32X035（F8U6）ではI2Cがデバッグの端子PC18 / PC19（かUSBの端子
// ja: PC16 / PC17）にしか出ていないので、PC18 / PC19とUSE_DEBUG_PADS 1にする。
static const int SDA_PIN = SDA;
static const int SCL_PIN = SCL;
// static const int SDA_PIN = PC18;
// static const int SCL_PIN = PC19;

// en: 1 when the pins above are the debug interface's pads: the debugger lets go of them until the next reset
// en: (no WCH-Link or OEP probe can attach), and a USB device is kept up so the next sketch uploads over USB.
// ja: 上の端子がデバッグの端子のときは1。次のリセットまでデバッガーが端子を手放す（WCH-LinkやOEPのprobeから
// ja: 接続できない）。次のスケッチをUSBで書き込めるよう、USBのデバイスを動かしておく。
#define USE_DEBUG_PADS 0

// en: The module's address: 0x3C on most, 0x3D when its address jumper is moved.
// ja: モジュールのアドレス。たいてい0x3C、アドレスのジャンパーを変えると0x3D。
static const uint8_t OLED_ADDR = 0x3C;

#if USE_DEBUG_PADS
#include <CH32RV.h>
// en: With the debug pads given away, USB is the only way to upload the next sketch: keep a USB device up
// en: (SerialUSB carries the DFU runtime), so the board's ch32rv-app:// port or serial port still uploads.
// ja: デバッグの端子を手放すと、次の書き込みはUSBしか無い。USBのデバイスを動かしておく（SerialUSBにDFUランタイムが
// ja: 付く）ので、基板のch32rv-app://の口かシリアルポートから書き込める。
#include <CH32RVUsbDevice.h>
#endif

// en: SH1106's RAM is 132 columns wide; a 128-pixel panel sits at column 2.
// ja: SH1106のRAMは132列あり、128ドットの画面は2列目から始まる。
static const uint8_t COLUMN_OFFSET = 2;

// en: 5x7 glyphs, ' ' (0x20) to '~' (0x7E), one byte a column, bit 0 at the top.
// ja: 5x7の字形。' '（0x20）から'~'（0x7E）、1列1バイト、bit 0が上。
static const uint8_t FONT[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5F, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, {0x24, 0x2A, 0x7F, 0x2A, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00}, {0x00, 0x1C, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1C, 0x00}, {0x08, 0x2A, 0x1C, 0x2A, 0x08}, {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02}, {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4B, 0x31}, {0x18, 0x14, 0x12, 0x7F, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1E}, {0x00, 0x36, 0x36, 0x00, 0x00},
    {0x00, 0x56, 0x36, 0x00, 0x00}, {0x08, 0x14, 0x22, 0x41, 0x00}, {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x00, 0x41, 0x22, 0x14, 0x08}, {0x02, 0x01, 0x51, 0x09, 0x06}, {0x32, 0x49, 0x79, 0x41, 0x3E},
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x09, 0x01},
    {0x3E, 0x41, 0x49, 0x49, 0x7A}, {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x0C, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01}, {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x3F, 0x40, 0x38, 0x40, 0x3F}, {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x07, 0x08, 0x70, 0x08, 0x07}, {0x61, 0x51, 0x49, 0x45, 0x43}, {0x00, 0x7F, 0x41, 0x41, 0x00},
    {0x02, 0x04, 0x08, 0x10, 0x20}, {0x00, 0x41, 0x41, 0x7F, 0x00}, {0x04, 0x02, 0x01, 0x02, 0x04},
    {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x01, 0x02, 0x04, 0x00}, {0x20, 0x54, 0x54, 0x54, 0x78},
    {0x7F, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20}, {0x38, 0x44, 0x44, 0x48, 0x7F},
    {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7E, 0x09, 0x01, 0x02}, {0x0C, 0x52, 0x52, 0x52, 0x3E},
    {0x7F, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7D, 0x40, 0x00}, {0x20, 0x40, 0x44, 0x3D, 0x00},
    {0x7F, 0x10, 0x28, 0x44, 0x00}, {0x00, 0x41, 0x7F, 0x40, 0x00}, {0x7C, 0x04, 0x18, 0x04, 0x78},
    {0x7C, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38}, {0x7C, 0x14, 0x14, 0x14, 0x08},
    {0x08, 0x14, 0x14, 0x18, 0x7C}, {0x7C, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x20},
    {0x04, 0x3F, 0x44, 0x40, 0x20}, {0x3C, 0x40, 0x40, 0x20, 0x7C}, {0x1C, 0x20, 0x40, 0x20, 0x1C},
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, {0x44, 0x28, 0x10, 0x28, 0x44}, {0x0C, 0x50, 0x50, 0x50, 0x3C},
    {0x44, 0x64, 0x54, 0x4C, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x7F, 0x00, 0x00},
    {0x00, 0x41, 0x36, 0x08, 0x00}, {0x08, 0x04, 0x08, 0x10, 0x08},
};

// en: One command byte (control byte 0x00 before it). False when the module did not acknowledge.
// ja: コマンド1バイト（前に制御バイト0x00）。モジュールが応答しなければfalse。
static bool command(uint8_t c)
{
    Wire.beginTransmission(OLED_ADDR);
    Wire.write(0x00);
    Wire.write(c);
    return Wire.endTransmission() == 0;
}

// en: Point the display's RAM at a page (0-7) and a column (0-127).
// ja: 表示側のRAMの書く位置を、ページ（0〜7）と列（0〜127）で指定する。
static void moveTo(uint8_t page, uint8_t column)
{
    const uint8_t c = column + COLUMN_OFFSET;
    command(0xB0 | page);
    command(0x00 | (c & 0x0F));
    command(0x10 | (c >> 4));
}

// en: Display data bytes (control byte 0x40), in pieces that fit Wire's 32-byte buffer.
// ja: 表示データ（制御バイト0x40）。Wireの32バイトのバッファに収まる大きさに分けて送る。
static void data(const uint8_t *bytes, size_t length)
{
    while (length > 0) {
        const size_t n = length < 16 ? length : 16;
        Wire.beginTransmission(OLED_ADDR);
        Wire.write(0x40);
        Wire.write(bytes, n);
        Wire.endTransmission();
        bytes += n;
        length -= n;
    }
}

static void clearScreen()
{
    static const uint8_t zeros[16] = {0};
    for (uint8_t page = 0; page < 8; page++) {
        moveTo(page, 0);
        for (uint8_t i = 0; i < 128 / 16; i++) {
            data(zeros, sizeof zeros);
        }
    }
}

// en: Text on one 8-pixel row (page 0-7) from a column, 6 pixels a character (5 and a gap), 21 to a row.
// ja: 8ドットの1行（ページ0〜7）に、列から文字を書く。1文字6ドット（5ドットと隙間）、1行21文字。
static void drawText(uint8_t page, uint8_t column, const char *text)
{
    moveTo(page, column);
    for (; *text && column <= 128 - 6; text++, column += 6) {
        const char ch = (*text >= 0x20 && *text <= 0x7E) ? *text : '?';
        uint8_t glyph[6];
        memcpy(glyph, FONT[ch - 0x20], 5);
        glyph[5] = 0;
        data(glyph, sizeof glyph);
    }
}

static bool oledBegin()
{
    // en: The usual SH1106 start: off, clock, 64 rows, no offset, start line 0, DC-DC on, mirrored
    // en: (connector at the top), contrast, precharge, VCOM, follow RAM, not inverted, on.
    // ja: SH1106の一般的な始め方: 消灯、クロック、64行、ずれ無し、開始行0、DC-DCを入れる、向き（端子が上）、
    // ja: コントラスト、プリチャージ、VCOM、RAMに従う、反転しない、点灯。
    static const uint8_t init[] = {0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40, 0xAD, 0x8B, 0xA1, 0xC8,
                                   0xDA, 0x12, 0x81, 0x80, 0xD9, 0x22, 0xDB, 0x35, 0xA4, 0xA6};
    for (uint8_t c : init) {
        if (!command(c)) {
            return false;
        }
    }
    clearScreen();
    return command(0xAF);
}

static bool ready;

void setup()
{
#if USE_DEBUG_PADS
    SerialUSB.begin();
    // en: Until the next reset no WCH-Link or OEP probe can attach: upload over USB (above).
    // ja: 次のリセットまでWCH-LinkやOEPのprobeから接続できない。書き込みはUSBで（上）。
    CH32RV.releaseDebugPins();
#endif
    if (!Wire.begin(SDA_PIN, SCL_PIN, 400000)) {
        return;   // en: these pins cannot carry I2C here / ja: この端子ではI2Cにできない
    }
    ready = oledBegin();
    if (ready) {
        drawText(0, 0, "Hello, SH1106!");
        drawText(2, 0, "CH32RV Arduino");
        drawText(4, 0, "SDA ");
        drawText(4, 24, digitalPinToName(SDA_PIN));
        drawText(4, 54, "SCL ");
        drawText(4, 78, digitalPinToName(SCL_PIN));
    }
}

void loop()
{
    if (!ready) {
        return;
    }
    static uint32_t last;
    if (millis() - last >= 500) {
        last = millis();
        char text[22];
        snprintf(text, sizeof text, "uptime %lu.%lu s   ", (unsigned long)(last / 1000),
                 (unsigned long)(last % 1000 / 100));
        drawText(6, 0, text);
    }
}
